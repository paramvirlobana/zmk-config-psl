## config/boards/shields/FlightDeck/Kconfig.defconfig
```kconfig
if SHIELD_FLIGHTDECK

config ZMK_KEYBOARD_NAME
    default "FlightDeck"

    endif
```
